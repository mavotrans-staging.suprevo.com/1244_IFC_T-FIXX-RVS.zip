Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T10:56:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 10:56:55 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{2DD7A09F-B93A-4977-B99D-6A59E5954732}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 10:56:55 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 10:56:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 10:56:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1244_T-FIXX RVS; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1244_T-FIXX RVS; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: 124421, NLRSnl_28_GM_MOD_1244-T-FIXX RVS_Mavotrans_R19:124421_M20x100:321786
In: Level 0
Type - Description: T-FIXX RVS M20-100; Classification: 28.20 (Default Classification); Material: RVS
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a (mm): 62 mm; d_nom: M20; I (mm): 100 mm
Type - Fire Protection - Brandwerendheid | Fire resistance rating: Niet getest | Not rated
Type - Identity Data - Artikelnummer | Article number: 124421; Beschrijving | Description: T-FIXX RVS M20-100; Certificaten | Certification: CE; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28.20; OmniClass Number: 23.25.10.27.11.11; OmniClass Title: Reinforcing Steel; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 124421_M20x100; URL: https://mavotrans.nl/producten/t-fixx-rvs.html; Verpakkingshoeveelheid | Sales packaging: Verpakking per 50 stuks | 50 pieces per box; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: RVS A4-80 anker met een plastic ring | RVS A4-80 anchor with a plastic ring
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_MOD_1244-T-FIXX RVS_Mavotrans_R19; Height narrowest piece: 5 mm; Height PVC: 5 mm; Height under narrowing: 3 mm; Length "a": 62 mm; Length "L": 100 mm; Radius "d-nom": 10 mm; Radius PVC 1: 16 mm; Radius PVC 2: 13.5 mm; Radius thread: 12 mm; Radius wrench size: 11 mm; Size bolt "d-nom": 20 mm; Thickness PVC ring: 1.5 mm; Thickness steel head 1: 2 mm; Thickness steel head 2: 3 mm; Upper narrowing: 5 mm; Wrench size: 22 mm
Type - Pset_ProductRequirements - Category: Generic Models
Material: RVS, kunststof
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_MOD_1244-T-FIXX RVS_Mavotrans_R19:124421_M20x100; sets with these values: 2
Constraints - Level: Level: Level 0; Offset: 100 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.00751747 m2; Volume: 0.0000247418 m3
Other - Family: NLRSnl_28_GM_MOD_1244-T-FIXX RVS_Mavotrans_R19: 124421_M20x100; Family and Type: NLRSnl_28_GM_MOD_1244-T-FIXX RVS_Mavotrans_R19: 124421_M20x100; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_MOD_1244-T-FIXX RVS_Mavotrans_R19: 124421_M20x100; Type Id: NLRSnl_28_GM_MOD_1244-T-FIXX RVS_Mavotrans_R19: 124421_M20x100
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover Settings: Rebar Cover 1
